Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Bond - Swivel Living Armchair - ver4.ifc
Time: 2025-11-04T16:19:30
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (16)
Name
 | Bond - Swivel Living Armchair_0 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_1 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_2 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_3 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_4 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_5 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_6 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_7 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_8 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_9 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_10 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_11 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_12 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_13 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_14 - ObjectType: SketchupGroup
 | Bond - Swivel Living Armchair_15 - ObjectType: SketchupGroup
